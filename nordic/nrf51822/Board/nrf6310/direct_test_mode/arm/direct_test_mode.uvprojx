# Keil uVision project direct_test_mode.uvprojx, settings and files
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.1
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: direct_test_mode +hex
  c flags: Optim=4 oTime=1 wLevel=2
  c define: NRF51 BOARD_NRF6310
  c misc: --c99
  c include: ..\..\..\..\Include\ble;..\..\..\..\Include
  asm misc: --cpreproc --cpreproc_opts='-DASSEMBLER_PREPROC__'
  memory RVCT4: ROM 0x16000 size 0x29000
  memory RVCT9: RAM 0x20002000 size 0x2000
  link misc: --remove
  group Source Code
    ../: main.c
  group Libraries
    ../../../../Source/ble/: ble_dtm.c
  group ::Device
    RTE/Device/nRF51822_xxAA/: arm_startup_nrf51.s system_nrf51.c
    RTE/Device/nRF51822_xxAB/: arm_startup_nrf51.s system_nrf51.c
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.1
  cpu: as above
  output: direct_test_mode +hex
  c flags: Optim=4 oTime=1 wLevel=2
  c define: NRF51 BOARD_NRF6310
  c misc: --c99
  c include: ..\..\..\..\Include\ble;..\..\..\..\Include
  asm misc: --cpreproc --cpreproc_opts='-DASSEMBLER_PREPROC__'
  memory RVCT4: ROM 0x16000 size 0x9000
  memory RVCT9: RAM 0x20002000 size 0x2000
  link misc: --remove
target nrf51822_xxaa (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.1
  cpu: as above
  output: direct_test_mode +hex
  c flags: Optim=4 oTime=1 wLevel=2
  c define: NRF51 BOARD_NRF6310
  c misc: --c99
  c include: ..\..\..\..\Include\ble;..\..\..\..\Include
  asm misc: --cpreproc --cpreproc_opts='-DASSEMBLER_PREPROC__'
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --remove
target nrf51822_xxab (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.1
  cpu: as above
  output: direct_test_mode +hex
  c flags: Optim=4 oTime=1 wLevel=2
  c define: NRF51 BOARD_NRF6310
  c misc: --c99
  c include: ..\..\..\..\Include\ble;..\..\..\..\Include
  asm misc: --cpreproc --cpreproc_opts='-DASSEMBLER_PREPROC__'
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --remove
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
