# Keil uVision project spi_master_example.uvprojx, settings and files
target nrf51822_xxaa (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: spi_master_example_arm +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 BOARD_NRF6310 SPI_MASTER_0_ENABLE
  c include: ..\..\..\..\Include;..\..\..\..\Include\sdk_soc;..\..\..\..\Include\app_common;..\
  memory RVCT4: ROM 0x00000000 size 0x00040000
  memory RVCT9: RAM 0x20000000 size 0x00004000
  group app
    ../: main.c
    ../../../../Source/: keil_arm_uv4.lnt
  group ::DEVICE
    RTE/Device/nRF51822_xxAA/: startup_arm_nrf51.s system_nrf51.c
  group lib
    ../../../../Source/spi_master/: spi_master.c
    ../../../../Source/nrf_delay/: nrf_delay.c
    ../../../../Source/sdk_soc/: nrf_soc.c
target nrf51822_xxab (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: as above
  output: spi_master_example_arm +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 BOARD_NRF6310 SPI_MASTER_0_ENABLE
  c include: as above
  memory RVCT4: ROM 0x00000000 size 0x00020000
  memory RVCT9: RAM 0x20000000 size 0x00004000
  group added to the first target's files
    RTE/Device/nRF51822_xxAB/: startup_arm_nrf51.s system_nrf51.c
  group left out of the first target's files
    RTE/Device/nRF51822_xxAA/: startup_arm_nrf51.s system_nrf51.c
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: as above
  output: spi_master_example_arm +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 BOARD_NRF6310 SPI_MASTER_0_ENABLE
  c include: as above
  memory RVCT4: ROM 0x00016000 size 0x00029000
  memory RVCT9: RAM 0x20002000 size 0x00002000
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: as above
  output: spi_master_example_arm +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 BOARD_NRF6310 SPI_MASTER_0_ENABLE
  c include: as above
  memory RVCT4: ROM 0x00016000 size 0x00009000
  memory RVCT9: RAM 0x20002000 size 0x00002000
  group added to the first target's files
    RTE/Device/nRF51822_xxAB/: startup_arm_nrf51.s system_nrf51.c
  group left out of the first target's files
    RTE/Device/nRF51822_xxAA/: startup_arm_nrf51.s system_nrf51.c
target nrf51822_xxaa_s120 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: as above
  output: spi_master_example_arm +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 BOARD_NRF6310 SPI_MASTER_0_ENABLE
  c include: as above
  memory RVCT4: ROM 0x00018000 size 0x00027000
  memory RVCT9: RAM 0x20002800 size 0x00001800
target nrf51822_xxab_s120 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: as above
  output: spi_master_example_arm +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 BOARD_NRF6310 SPI_MASTER_0_ENABLE
  c include: as above
  memory RVCT4: ROM 0x00018000 size 0x00007000
  memory RVCT9: RAM 0x20002800 size 0x00001800
  group added to the first target's files
    RTE/Device/nRF51822_xxAB/: startup_arm_nrf51.s system_nrf51.c
  group left out of the first target's files
    RTE/Device/nRF51822_xxAA/: startup_arm_nrf51.s system_nrf51.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
