# Keil uVision project spi_master_example.uvproj, settings and files
target nrf51822_xxaa (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: spi_master_example_arm +hex
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: NRF51 BOARD_NRF6310 SPI_MASTER_0_ENABLE
  c misc: --c99
  c include: ..\..\..\..\Include;..\..\..\..\Include\sdk_soc;..\..\..\..\Include\app_common;..\
  library: MicroLIB
  memory RVCT4: ROM 0x00000000 size 0x00040000
  memory RVCT9: RAM 0x20000000 size 0x00004000
  group app
    ../: main.c
    ../../../../Source/: keil_arm_uv4.lnt
  group core
    ../../../../Source/templates/arm/: arm_startup_nrf51.s
    ../../../../Source/templates/: system_nrf51.c
  group lib
    ../../../../Source/spi_master/: spi_master.c
    ../../../../Source/nrf_delay/: nrf_delay.c
    ../../../../Source/sdk_soc/: nrf_soc.c
target nrf51822_xxab (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  cpu: as above
  output: spi_master_example_arm +hex
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: NRF51 BOARD_NRF6310 SPI_MASTER_0_ENABLE
  c misc: --c99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x00000000 size 0x00020000
  memory RVCT9: RAM 0x20000000 size 0x00004000
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: as above
  output: spi_master_example_arm +hex
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: NRF51 BOARD_NRF6310 SPI_MASTER_0_ENABLE
  c misc: --c99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x00016000 size 0x00029000
  memory RVCT9: RAM 0x20002000 size 0x00002000
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  cpu: as above
  output: spi_master_example_arm +hex
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: NRF51 BOARD_NRF6310 SPI_MASTER_0_ENABLE
  c misc: --c99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x00016000 size 0x00009000
  memory RVCT9: RAM 0x20002000 size 0x00002000
target nrf51822_xxaa_s120 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: as above
  output: spi_master_example_arm +hex
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: NRF51 BOARD_NRF6310 SPI_MASTER_0_ENABLE
  c misc: --c99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x00018000 size 0x00027000
  memory RVCT9: RAM 0x20002800 size 0x00001800
target nrf51822_xxab_s120 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  cpu: as above
  output: spi_master_example_arm +hex
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: NRF51 BOARD_NRF6310 SPI_MASTER_0_ENABLE
  c misc: --c99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x00018000 size 0x00007000
  memory RVCT9: RAM 0x20002800 size 0x00001800
