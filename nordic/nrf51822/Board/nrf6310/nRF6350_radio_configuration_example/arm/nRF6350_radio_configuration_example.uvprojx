# Keil uVision project nRF6350_radio_configuration_example.uvprojx, settings and files
target nrf51822_xxaa (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: nRF6350_radio_configuration_example_arm +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 BOARD_NRF6310
  c include: ..\..\..\..\Include;..\..\..\..\Include\ext_sensors;..\
  memory RVCT4: ROM 0x00000000 size 0x00040000
  memory RVCT9: RAM 0x20000000 size 0x00004000
  group app
    ../: main.c
  group ::DEVICE
    RTE/Device/nRF51822_xxAA/: system_nrf51.c arm_startup_nrf51.s
  group lib
    ../../../../Source/ext_sensors/nRF6350/: nRF6350.c
    ../../../../Source/twi_master/: twi_hw_master.c
target nrf51822_xxab (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: as above
  output: nRF6350_radio_configuration_example_arm +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 BOARD_NRF6310
  c include: ..\..\..\..\Include;..\..\..\..\Include\ext_sensors;..\
  memory RVCT4: ROM 0x00000000 size 0x00020000
  memory RVCT9: RAM 0x20000000 size 0x00004000
  group added to the first target's files
    RTE/Device/nRF51822_xxAB/: arm_startup_nrf51.s system_nrf51.c
  group left out of the first target's files
    RTE/Device/nRF51822_xxAA/: arm_startup_nrf51.s system_nrf51.c
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: as above
  output: nRF6350_radio_configuration_example_arm +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 BOARD_NRF6310
  c include: ..\..\..\..\Include;..\..\..\..\Include\ext_sensors;..\
  memory RVCT4: ROM 0x00016000 size 0x00029000
  memory RVCT9: RAM 0x20002000 size 0x00002000
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: as above
  output: nRF6350_radio_configuration_example_arm +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 BOARD_NRF6310
  c include: ..\..\..\..\Include;..\..\..\..\Include\ext_sensors;..\
  memory RVCT4: ROM 0x00016000 size 0x00009000
  memory RVCT9: RAM 0x20002000 size 0x00002000
  group added to the first target's files
    RTE/Device/nRF51822_xxAB/: arm_startup_nrf51.s system_nrf51.c
  group left out of the first target's files
    RTE/Device/nRF51822_xxAA/: arm_startup_nrf51.s system_nrf51.c
target nrf51822_xxaa_s120 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: as above
  output: nRF6350_radio_configuration_example_arm +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 BOARD_NRF6310
  c include: ..\..\..\..\Include;..\..\..\..\Include\ext_sensors;..\
  memory RVCT4: ROM 0x00018000 size 0x00027000
  memory RVCT9: RAM 0x20002800 size 0x00001800
target nrf51822_xxab_s120 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: as above
  output: nRF6350_radio_configuration_example_arm +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 BOARD_NRF6310
  c include: ..\..\..\..\Include;..\..\..\..\Include\ext_sensors;..\
  memory RVCT4: ROM 0x00018000 size 0x00007000
  memory RVCT9: RAM 0x20002800 size 0x00001800
  group added to the first target's files
    RTE/Device/nRF51822_xxAB/: arm_startup_nrf51.s system_nrf51.c
  group left out of the first target's files
    RTE/Device/nRF51822_xxAA/: arm_startup_nrf51.s system_nrf51.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
