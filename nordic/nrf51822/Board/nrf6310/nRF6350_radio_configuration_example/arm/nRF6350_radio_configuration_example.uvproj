# Keil uVision project nRF6350_radio_configuration_example.uvproj, settings and files
target nrf51822_xxaa (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: nRF6350_radio_configuration_example_arm +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51 BOARD_NRF6310
  c misc: --c99
  c include: ..\..\..\..\Include;..\..\..\..\Include\ext_sensors;..\
  library: MicroLIB
  memory RVCT4: ROM 0x00000000 size 0x00040000
  memory RVCT9: RAM 0x20000000 size 0x00004000
  group app
    ../: main.c
  group core
    ../../../../Source/templates/: system_nrf51.c
    ../../../../Source/templates/arm/: arm_startup_nrf51.s
  group lib
    ../../../../Source/ext_sensors/nRF6350/: nRF6350.c
    ../../../../Source/twi_master/: twi_hw_master.c
target nrf51822_xxab (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  cpu: as above
  output: nRF6350_radio_configuration_example_arm +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51 BOARD_NRF6310
  c misc: --c99
  c include: ..\..\..\..\Include;..\..\..\..\Include\ext_sensors;..\
  library: MicroLIB
  memory RVCT4: ROM 0x00000000 size 0x00020000
  memory RVCT9: RAM 0x20000000 size 0x00004000
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: as above
  output: nRF6350_radio_configuration_example_arm +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51 BOARD_NRF6310
  c misc: --c99
  c include: ..\..\..\..\Include;..\..\..\..\Include\ext_sensors;..\
  library: MicroLIB
  memory RVCT4: ROM 0x00016000 size 0x00029000
  memory RVCT9: RAM 0x20002000 size 0x00002000
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  cpu: as above
  output: nRF6350_radio_configuration_example_arm +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51 BOARD_NRF6310
  c misc: --c99
  c include: ..\..\..\..\Include;..\..\..\..\Include\ext_sensors;..\
  library: MicroLIB
  memory RVCT4: ROM 0x00016000 size 0x00009000
  memory RVCT9: RAM 0x20002000 size 0x00002000
target nrf51822_xxaa_s120 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: as above
  output: nRF6350_radio_configuration_example_arm +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51 BOARD_NRF6310
  c misc: --c99
  c include: ..\..\..\..\Include;..\..\..\..\Include\ext_sensors;..\
  library: MicroLIB
  memory RVCT4: ROM 0x00018000 size 0x00027000
  memory RVCT9: RAM 0x20002800 size 0x00001800
target nrf51822_xxab_s120 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  cpu: as above
  output: nRF6350_radio_configuration_example_arm +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51 BOARD_NRF6310
  c misc: --c99
  c include: ..\..\..\..\Include;..\..\..\..\Include\ext_sensors;..\
  library: MicroLIB
  memory RVCT4: ROM 0x00018000 size 0x00007000
  memory RVCT9: RAM 0x20002800 size 0x00001800
