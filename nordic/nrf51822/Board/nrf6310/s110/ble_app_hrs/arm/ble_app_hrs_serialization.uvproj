# Keil uVision project ble_app_hrs_serialization.uvproj, settings and files
target nrf51822_xxab_spi (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_app_hrs_serialization +hex
  c flags: Optim=4 wLevel=2
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD SVCALL_AS_NORMAL_FUNCTION BOARD_NRF6310 S110 SPI_MASTER_0_ENABLE
  c misc: --c99
  c include: ..;..\..\..\..\..\Include\serialization\application;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\device_manager;..\..\..\..\..\Include\ble\device_manager;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\ble\device_manager;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\s110;..\..\..\..\..\Include\sdk_soc;..\..\..\..\..\Include\sd_common;..\..\..\..\..\Include\serialization\application\transport;..\..\..\..\..\Include\serialization\application\codecs\s110;..\..\..\..\..\Include\serialization\application\codecs\s110\serializers;..\..\..\..\..\Include\serialization\common;..\..\..\..\..\Include\serialization\common\transport;..\..\..\..\..\Include\serialization\common\struct_ser\s110;..\..\..\..\..\Include\sdk;..\..\..\..\..\Include\bootloader_dfu
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1f000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Startup Code
    ./../../../../../Source/templates/arm/: arm_startup_nrf51.s
    ./../../../../../Source/templates/: system_nrf51.c
  group Source Code
    ./../: main.c
  group Services
    ../../../../../Source/ble/ble_services/: ble_dis.c ble_bas.c ble_hrs.c
  group Libraries
    ../../../../../Source/ble/: ble_error_log.c ble_advdata.c ble_sensorsim.c ble_conn_params.c ble_debug_assert_handler.c
    ../../../../../Source/ble/ble_services/: ble_srv_common.c
    ../../../../../Source/sd_common/: softdevice_handler.c
    ../../../../../Source/app_common/: crc16.c app_trace.c
    ../../../../../Source/ble/device_manager/: device_manager_peripheral.c
    ../../../../../Source/simple_uart/: simple_uart.c
    ../../../../../Source/serialization/application/hal/: app_util_platform.c
  group ser_codecs
    ../../../../../Source/serialization/application/codecs/s110/serializers/: ble_event.c ble_evt_tx_complete.c ble_gap_address_get.c ble_gap_address_set.c ble_gap_adv_data_set.c ble_gap_adv_start.c ble_gap_adv_stop.c ble_gap_appearance_get.c ble_gap_appearance_set.c ble_gap_auth_key_reply.c ble_gap_authenticate.c ble_gap_conn_param_update.c ble_gap_conn_sec_get.c ble_gap_device_name_get.c ble_gap_device_name_set.c ble_gap_disconnect.c ble_gap_evt_auth_key_request.c ble_gap_evt_auth_status.c ble_gap_evt_conn_param_update.c ble_gap_evt_conn_sec_update.c ble_gap_evt_connected.c ble_gap_evt_disconnected.c ble_gap_evt_passkey_display.c ble_gap_evt_rssi_changed.c ble_gap_evt_sec_info_request.c ble_gap_evt_sec_params_request.c ble_gap_evt_timeout.c ble_gap_ppcp_get.c ble_gap_ppcp_set.c ble_gap_rssi_start.c ble_gap_rssi_stop.c ble_gap_sec_info_reply.c ble_gap_sec_params_reply.c ble_gap_tx_power_set.c ble_gattc_char_value_by_uuid_read.c ble_gattc_char_values_read.c ble_gattc_characteristics_discover.c ble_gattc_descriptors_discover.c ble_gattc_evt_char_disc_rsp.c ble_gattc_evt_char_val_by_uuid_read_rsp.c ble_gattc_evt_char_vals_read_rsp.c ble_gattc_evt_desc_disc_rsp.c ble_gattc_evt_hvx.c ble_gattc_evt_prim_srvc_disc_rsp.c ble_gattc_evt_read_rsp.c ble_gattc_evt_rel_disc_rsp.c ble_gattc_evt_timeout.c ble_gattc_evt_write_rsp.c ble_gattc_hv_confirm.c ble_gattc_primary_services_discover.c ble_gattc_read.c ble_gattc_relationships_discover.c ble_gattc_write.c ble_gatts_characteristic_add.c ble_gatts_descriptor_add.c ble_gatts_evt_hvc.c ble_gatts_evt_rw_authorize_request.c ble_gatts_evt_sc_confirm.c ble_gatts_evt_sys_attr_missing.c ble_gatts_evt_timeout.c ble_gatts_evt_write.c ble_gatts_hvx.c ble_gatts_include_add.c ble_gatts_rw_authorize_reply.c ble_gatts_service_add.c ble_gatts_service_changed.c ble_gatts_sys_attr_get.c ble_gatts_sys_attr_set.c ble_gatts_value_get.c ble_gatts_value_set.c ble_l2cap_cid_register.c ble_l2cap_cid_unregister.c ble_l2cap_evt_rx.c ble_l2cap_tx.c ble_tx_buffer_count_get.c ble_uuid_decode.c ble_uuid_encode.c ble_uuid_vs_add.c ble_version_get.c power_system_off.c temp_get.c ble_enable.c ble_opt_get.c ble_opt_set.c
    ../../../../../Source/serialization/common/struct_ser/s110/: ble_gap_struct_serialization.c ble_gattc_struct_serialization.c ble_gatts_struct_serialization.c ble_struct_serialization.c
    ../../../../../Source/serialization/common/: ble_serialization.c cond_field_serialization.c
  group ser_codecs_mw
    ../../../../../Source/serialization/application/codecs/s110/middleware/: app_mw_ble.c app_mw_ble_gap.c app_mw_ble_gattc.c app_mw_ble_gatts.c app_mw_ble_l2cap.c app_mw_nrf_soc.c
  group ser_utils
    ../../../../../Source/serialization/application/transport/: ser_softdevice_handler.c ser_sd_transport.c app_mailbox.c
    ../../../../../Source/serialization/common/transport/: ser_hal_transport.c
  group ser_hal
    ../../../../../Source/nrf_delay/: nrf_delay.c
    ../../../../../Source/ble/: ble_flash.c
    ../../../../../Source/app_common/: app_timer.c app_scheduler.c
    ../../../../../Source/serialization/application/hal/: app_gpiote_fast_detect.c pstorage.c ser_app_hal_nrf51.c ser_app_power_system_off.c
  group ser_hal_serial
    ../../../../../Source/spi_master/: spi_master.c
    ../../../../../Source/serialization/application/hal/: ser_phy_nrf51_spi_master.c ser_phy_nrf51_spi_5W_master.c spi_5W_master.c ser_phy_nrf51_uart_stm_app.c
    ../../../../../Source/serialization/common/transport/: ser_phy_nrf51_uart.c ser_phy_hci.c ser_phy_hci_slip.c
    ../../../../../Source/app_common/: app_uart.c
target nrf51822_xxaa_spi (256K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: as above
  output: ble_app_hrs_serialization +hex
  c flags: Optim=4 wLevel=2
  c define: as above
  c misc: --c99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x3f000
  memory RVCT9: RAM 0x20000000 size 0x4000
target nrf51822_xxab_spi_5w (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: as above
  output: ble_app_hrs_serialization +hex
  c flags: Optim=4 wLevel=2
  c define: as above
  c misc: --c99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1f000
  memory RVCT9: RAM 0x20000000 size 0x4000
target nrf51822_xxaa_spi_5w (256K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: as above
  output: ble_app_hrs_serialization +hex
  c flags: Optim=4 wLevel=2
  c define: as above
  c misc: --c99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x3f000
  memory RVCT9: RAM 0x20000000 size 0x4000
target nrf51822_xxab_uart (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: as above
  output: ble_app_hrs_serialization +hex
  c flags: Optim=4 wLevel=2
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD SVCALL_AS_NORMAL_FUNCTION BOARD_NRF6310 S110
  c misc: --c99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1f000
  memory RVCT9: RAM 0x20000000 size 0x4000
target nrf51822_xxaa_uart (256K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: as above
  output: ble_app_hrs_serialization +hex
  c flags: Optim=4 wLevel=2
  c define: as above
  c misc: --c99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x3f000
  memory RVCT9: RAM 0x20000000 size 0x4000
target nrf51822_xxab_uart_stm (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: as above
  output: ble_app_hrs_serialization +hex
  c flags: Optim=4 wLevel=2
  c define: as above
  c misc: --c99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1f000
  memory RVCT9: RAM 0x20000000 size 0x4000
target nrf51822_xxaa_uart_stm (256K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: as above
  output: ble_app_hrs_serialization +hex
  c flags: Optim=4 wLevel=2
  c define: as above
  c misc: --c99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x3f000
  memory RVCT9: RAM 0x20000000 size 0x4000
target nrf51822_xxab_uart_hci (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: as above
  output: ble_app_hrs_serialization +hex
  c flags: Optim=4 wLevel=2
  c define: as above
  c misc: --c99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1f000
  memory RVCT9: RAM 0x20000000 size 0x4000
target nrf51822_xxaa_uart_hci (256K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: as above
  output: ble_app_hrs_serialization +hex
  c flags: Optim=4 wLevel=2
  c define: as above
  c misc: --c99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x3f000
  memory RVCT9: RAM 0x20000000 size 0x4000
