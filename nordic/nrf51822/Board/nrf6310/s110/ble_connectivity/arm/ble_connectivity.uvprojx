# Keil uVision project ble_connectivity.uvprojx, settings and files
target nrf51822_xxab_spi_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_connectivity +hex
  c flags: Optim=4 uC99=1
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD SER_CONNECTIVITY BOARD_NRF6310
  c include: ..\..\..\..\..\Include;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\s110;..\..\..\..\..\Include\sd_common;..\..\..\..\..\Include\serialization\connectivity;..\..\..\..\..\Include\serialization\common;..\..\..\..\..\Include\serialization\common\transport;..\..\..\..\..\Include\serialization\common\struct_ser\s110;..\..\..\..\..\Include\serialization\connectivity\transport;..\..\..\..\..\Include\serialization\connectivity\codecs\s110\serializers;..\..\..\..\..\Include\serialization\connectivity\codecs\s110\middleware;..\..\..\..\..\Include\serialization\connectivity\codecs\common;..\..\..\..\..\Source\serialization\connectivity\codecs\s110\middleware;..\..\..\..\..\Include\app_common
  memory RVCT4: ROM 0x16000 size 0xa000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group ::Device
    RTE/Device/nRF51822_xxAA/: arm_startup_nrf51.s system_nrf51.c
    RTE/Device/nRF51822_xxAB/: arm_startup_nrf51.s system_nrf51.c
  group main
    ./../: main.c
    ../../../../../Source/serialization/connectivity/: ser_conn_pkt_decoder.c ser_conn_cmd_decoder.c ser_conn_dtm_cmd_decoder.c ser_conn_event_encoder.c ser_conn_error_handling.c ser_conn_handlers.c
  group Libraries
    ../../../../../Source/app_common/: app_gpiote.c crc16.c app_timer.c
    ../../../../../Source/ble/: ble_debug_assert_handler.c ble_error_log.c
    ../../../../../Source/sd_common/: softdevice_handler.c
    ../../../../../Source/serialization/connectivity/: app_scheduler.c
    ../../../../../Source/serialization/application/transport/: app_mailbox.c
    ../../../../../Source/serialization/common/transport/debug/: debug_hci_nrf6310.c
  group transport
    ../../../../../Source/serialization/common/transport/: ser_hal_transport.c
  group dtm
    ../../../../../Source/ble/: ble_dtm.c
    ../../../../../Source/serialization/connectivity/hal/: dtm_uart.c
  group codecs
    ../../../../../Source/serialization/connectivity/codecs/common/: ble_dtm_init.c
    ../../../../../Source/serialization/connectivity/codecs/s110/serializers/: ble_event.c ble_evt_tx_complete.c ble_gap_address_get.c ble_gap_address_set.c ble_gap_adv_data_set.c ble_gap_adv_start.c ble_gap_adv_stop.c ble_gap_appearance_get.c ble_gap_appearance_set.c ble_gap_auth_key_reply.c ble_gap_authenticate.c ble_gap_conn_param_update.c ble_gap_conn_sec_get.c ble_gap_device_name_get.c ble_gap_device_name_set.c ble_gap_disconnect.c ble_gap_evt_auth_key_request.c ble_gap_evt_auth_status.c ble_gap_evt_conn_param_update.c ble_gap_evt_conn_sec_update.c ble_gap_evt_connected.c ble_gap_evt_disconnected.c ble_gap_evt_passkey_display.c ble_gap_evt_rssi_changed.c ble_gap_evt_sec_info_request.c ble_gap_evt_sec_params_request.c ble_gap_evt_timeout.c ble_gap_ppcp_get.c ble_gap_ppcp_set.c ble_gap_rssi_start.c ble_gap_rssi_stop.c ble_gap_sec_info_reply.c ble_gap_sec_params_reply.c ble_gap_tx_power_set.c ble_gattc_char_value_by_uuid_read.c ble_gattc_char_values_read.c ble_gattc_characteristics_discover.c ble_gattc_descriptors_discover.c ble_gattc_evt_char_disc_rsp.c ble_gattc_evt_char_val_by_uuid_read_rsp.c ble_gattc_evt_char_vals_read_rsp.c ble_gattc_evt_desc_disc_rsp.c ble_gattc_evt_hvx.c ble_gattc_evt_prim_srvc_disc_rsp.c ble_gattc_evt_read_rsp.c ble_gattc_evt_rel_disc_rsp.c ble_gattc_evt_timeout.c ble_gattc_evt_write_rsp.c ble_gattc_hv_confirm.c ble_gattc_primary_services_discover.c ble_gattc_read.c ble_gattc_relationships_discover.c ble_gattc_write.c ble_gatts_characteristic_add.c ble_gatts_descriptor_add.c ble_gatts_evt_hvc.c ble_gatts_evt_rw_authorize_request.c ble_gatts_evt_sc_confirm.c ble_gatts_evt_sys_attr_missing.c ble_gatts_evt_timeout.c ble_gatts_evt_write.c ble_gatts_hvx.c ble_gatts_include_add.c ble_gatts_rw_authorize_reply.c ble_gatts_service_add.c ble_gatts_service_changed.c ble_gatts_sys_attr_get.c ble_gatts_sys_attr_set.c ble_gatts_value_get.c ble_gatts_value_set.c ble_l2cap_cid_register.c ble_l2cap_cid_unregister.c ble_l2cap_evt_rx.c ble_l2cap_tx.c ble_tx_buffer_count_get.c ble_uuid_decode.c ble_uuid_encode.c ble_uuid_vs_add.c ble_version_get.c power_system_off.c temp_get.c ble_enable.c ble_opt_get.c ble_opt_id_pre_decoder.c ble_opt_set.c
    ../../../../../Source/serialization/common/struct_ser/s110/: ble_gap_struct_serialization.c ble_gattc_struct_serialization.c ble_gatts_struct_serialization.c ble_struct_serialization.c
    ../../../../../Source/serialization/common/: ble_serialization.c cond_field_serialization.c
  group codecs_mw
    ../../../../../Source/serialization/connectivity/codecs/s110/middleware/: conn_mw_ble.c conn_mw_ble_gap.c conn_mw_ble_gattc.c conn_mw_ble_gatts.c conn_mw_ble_l2cap.c conn_mw_nrf_soc.c
    ../../../../../Source/serialization/connectivity/codecs/common/: conn_mw.c
  group spi_phy
    ../../../../../Source/spi_slave/: spi_slave.c
    ../../../../../Source/serialization/connectivity/hal/: ser_phy_nrf51_spi_slave.c ser_phy_nrf51_spi_5W_slave.c
  group uart_phy
    ../../../../../Source/serialization/common/transport/: ser_phy_nrf51_uart.c ser_phy_hci.c ser_phy_hci_slip.c
    ../../../../../Source/app_common/: app_uart.c
  group uart_stm_phy
    ../../../../../Source/serialization/connectivity/hal/: ser_phy_nrf51_uart_stm_conn.c
target nrf51822_xxaa_spi_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: as above
  output: ble_connectivity +hex
  c flags: Optim=4 uC99=1
  c define: as above
  c include: ..\..\..\..\..\Include;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\s110;..\..\..\..\..\Include\sd_common;..\..\..\..\..\Include\serialization\common;..\..\..\..\..\Include\serialization\common\transport;..\..\..\..\..\Include\serialization\common\struct_ser\s110;..\..\..\..\..\Include\serialization\connectivity;..\..\..\..\..\Include\serialization\connectivity\transport;..\..\..\..\..\Include\serialization\connectivity\codecs\s110\serializers;..\..\..\..\..\Include\serialization\connectivity\codecs\s110\middleware;..\..\..\..\..\Include\serialization\connectivity\codecs\common;..\..\..\..\..\Source\serialization\connectivity\codecs\s110\middleware;..\..\..\..\..\Include\app_common
  memory RVCT4: ROM 0x16000 size 0x2a000
  memory RVCT9: RAM 0x20002000 size 0x2000
target nrf51822_xxab_spi_5w_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: as above
  output: ble_connectivity +hex
  c flags: Optim=4 uC99=1
  c define: as above
  c include: as above
  memory RVCT4: ROM 0x16000 size 0xa000
  memory RVCT9: RAM 0x20002000 size 0x2000
target nrf51822_xxaa_spi_5w_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: as above
  output: ble_connectivity +hex
  c flags: Optim=4 uC99=1
  c define: as above
  c include: as above
  memory RVCT4: ROM 0x16000 size 0x2a000
  memory RVCT9: RAM 0x20002000 size 0x2000
target nrf51822_xxab_uart_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: as above
  output: ble_connectivity +hex
  c flags: Optim=4 uC99=1
  c define: as above
  c include: as above
  memory RVCT4: ROM 0x16000 size 0xa000
  memory RVCT9: RAM 0x20002000 size 0x2000
target nrf51822_xxaa_uart_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: as above
  output: ble_connectivity +hex
  c flags: Optim=4 uC99=1
  c define: as above
  c include: ..\..\..\..\..\Include;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\s110;..\..\..\..\..\Include\sd_common;..\..\..\..\..\Include\serialization\common;..\..\..\..\..\Include\serialization\common\transport;..\..\..\..\..\Include\serialization\common\struct_ser\s110;..\..\..\..\..\Include\serialization\connectivity;..\..\..\..\..\Include\serialization\connectivity\transport;..\..\..\..\..\Include\serialization\connectivity\codecs\s110\serializers;..\..\..\..\..\Include\serialization\connectivity\codecs\s110\middleware;..\..\..\..\..\Include\serialization\connectivity\codecs\common;..\..\..\..\..\Source\serialization\connectivity\codecs\s110\middleware;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\serialization\application\transport
  library: MicroLIB
  memory RVCT4: ROM 0x16000 size 0x2a000
  memory RVCT9: RAM 0x20002000 size 0x2000
target nrf51822_xxab_uart_stm_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: as above
  output: ble_connectivity +hex
  c flags: Optim=4 uC99=1
  c define: as above
  c include: as above
  memory RVCT4: ROM 0x16000 size 0xa000
  memory RVCT9: RAM 0x20002000 size 0x2000
target nrf51822_xxaa_uart_stm_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: as above
  output: ble_connectivity +hex
  c flags: Optim=4 uC99=1
  c define: as above
  c include: as above
  memory RVCT4: ROM 0x16000 size 0x2a000
  memory RVCT9: RAM 0x20002000 size 0x2000
target nrf51822_xxab_uart_hci_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: as above
  output: ble_connectivity +hex
  c flags: Optim=4 uC99=1
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD SER_CONNECTIVITY BOARD_NRF6310 HCI_TIMER2 SER_PHY_HCI_DEBUG_ENABLE
  c include: ..\..\..\..\..\Include;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\s110;..\..\..\..\..\Include\sd_common;..\..\..\..\..\Include\serialization\common;..\..\..\..\..\Include\serialization\common\transport;..\..\..\..\..\Include\serialization\common\struct_ser\s110;..\..\..\..\..\Include\serialization\connectivity;..\..\..\..\..\Include\serialization\connectivity\transport;..\..\..\..\..\Include\serialization\connectivity\codecs\s110\serializers;..\..\..\..\..\Include\serialization\connectivity\codecs\s110\middleware;..\..\..\..\..\Include\serialization\connectivity\codecs\common;..\..\..\..\..\Source\serialization\connectivity\codecs\s110\middleware;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\serialization\application\transport;..\..\..\..\..\Source\serialization\common\transport\debug
  library: MicroLIB
  memory RVCT4: ROM 0x16000 size 0x2a000
  memory RVCT9: RAM 0x20002000 size 0x2000
target nrf51822_xxaa_uart_hci_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: as above
  output: ble_connectivity +hex
  c flags: Optim=4 uC99=1
  c define: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x16000 size 0xa000
  memory RVCT9: RAM 0x20002000 size 0x2000
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
