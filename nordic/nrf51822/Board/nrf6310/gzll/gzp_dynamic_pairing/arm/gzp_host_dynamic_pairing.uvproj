# Keil uVision project gzp_host_dynamic_pairing.uvproj, settings and files
target nrf51822_xxaa (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: gzll_host_dynamic_pairing +hex
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: NRF51, NRF51822_QFAA_CA
  c misc: --c99
  c include: ..\..\..\..\..\Include\gzll;..\..\..\..\..\Include\gzp;..\..\..\..\..\Include;..\
  asm include: ..\
  library: MicroLIB
  memory RVCT4: ROM 0x00000000 size 0x00040000
  memory RVCT9: RAM 0x20000000 size 0x00004000
  link misc: --info=inline
  group app
    ../: main_host_dynamic_pairing.c
  group system
    ../../../../../Source/templates/arm/: arm_startup_nrf51.s
    ../../../../../Source/templates/: system_nrf51.c
  group lib
    ../../../../../Lib/gzll/arm/: gzll_arm.lib
  group gzp
    ../../../../../Source/nrf_ecb/: nrf_ecb.c
    ../../../../../Source/nrf_nvmc/: nrf_nvmc.c
    ../../../../../Source/gzp/: nrf_gzp.c nrf_gzp_host.c nrf_gzp_host_nrf51.c
target nrf51822_xxab (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  cpu: as above
  output: gzll_host_dynamic_pairing +hex
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: NRF51, NRF51822_QFAA_CA
  c misc: --c99
  c include: as above
  asm include: ..\
  library: MicroLIB
  memory RVCT4: ROM 0x00000000 size 0x00020000
  memory RVCT9: RAM 0x20000000 size 0x00004000
  link misc: --info=inline
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: as above
  output: gzll_host_dynamic_pairing +hex
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: NRF51, NRF51822_QFAA_CA
  c misc: --c99
  c include: as above
  asm include: ..\
  library: MicroLIB
  memory RVCT4: ROM 0x00016000 size 0x00029000
  memory RVCT9: RAM 0x20002000 size 0x00002000
  link misc: --info=inline
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  cpu: as above
  output: gzll_host_dynamic_pairing +hex
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: NRF51, NRF51822_QFAA_CA
  c misc: --c99
  c include: as above
  asm include: ..\
  library: MicroLIB
  memory RVCT4: ROM 0x00016000 size 0x00009000
  memory RVCT9: RAM 0x20002000 size 0x00002000
  link misc: --info=inline
target nrf51822_xxaa_s120 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: as above
  output: gzll_host_dynamic_pairing +hex
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: NRF51, NRF51822_QFAA_CA
  c misc: --c99
  c include: as above
  asm include: ..\
  library: MicroLIB
  memory RVCT4: ROM 0x00018000 size 0x00027000
  memory RVCT9: RAM 0x20002800 size 0x00001800
  link misc: --info=inline
target nrf51822_xxab_s120 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  cpu: as above
  output: gzll_host_dynamic_pairing +hex
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: NRF51, NRF51822_QFAA_CA
  c misc: --c99
  c include: as above
  asm include: ..\
  library: MicroLIB
  memory RVCT4: ROM 0x00018000 size 0x00007000
  memory RVCT9: RAM 0x20002800 size 0x00001800
  link misc: --info=inline
