# Keil uVision project gzp_desktop_mouse_keyboard_emulator_nrf51.uvprojx, settings and files
target nrf51822_xxaa (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: gzll_nrfready_desktop_device_emulator_nrf51 +hex
  c flags: Optim=1 uC99=1
  c define: NRF51, NRF51822_QFAA_CA
  c include: ..\;..\..\..\..\..\Include;..\..\..\..\..\Include\gzll;..\..\..\..\..\Include\gzp
  memory RVCT4: ROM 0x00000000 size 0x00040000
  memory RVCT9: RAM 0x20000000 size 0x00004000
  group app
    ../: main_mouse_keyboard_emulator_nrf51.c keyboard_emulator.c mouse_sensor_emulator.c
  group ::DEVICE
    RTE/Device/nRF51822_xxAA/: arm_startup_nrf51.s system_nrf51.c
  group lib
    ../../../../../Lib/gzll/arm/: gzll_arm.lib
  group gzp
    ../../../../../Source/gzp/: nrf_gzp_device.c nrf_gzp.c
    ../../../../../Source/nrf_ecb/: nrf_ecb.c
    ../../../../../Source/nrf_nvmc/: nrf_nvmc.c
target nrf51822_xxab (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: as above
  output: gzll_nrfready_desktop_device_emulator_nrf51 +hex
  c flags: Optim=1 uC99=1
  c define: NRF51, NRF51822_QFAA_CA
  c include: as above
  memory RVCT4: ROM 0x00000000 size 0x00020000
  memory RVCT9: RAM 0x20000000 size 0x00004000
  group added to the first target's files
    RTE/Device/nRF51822_xxAB/: arm_startup_nrf51.s system_nrf51.c
  group left out of the first target's files
    RTE/Device/nRF51822_xxAA/: arm_startup_nrf51.s system_nrf51.c
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: as above
  output: gzll_nrfready_desktop_device_emulator_nrf51 +hex
  c flags: Optim=1 uC99=1
  c define: NRF51, NRF51822_QFAA_CA
  c include: as above
  memory RVCT4: ROM 0x00016000 size 0x00029000
  memory RVCT9: RAM 0x20002000 size 0x00002000
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: as above
  output: gzll_nrfready_desktop_device_emulator_nrf51 +hex
  c flags: Optim=1 uC99=1
  c define: NRF51, NRF51822_QFAA_CA
  c include: as above
  memory RVCT4: ROM 0x00016000 size 0x00009000
  memory RVCT9: RAM 0x20002000 size 0x00002000
  group added to the first target's files
    RTE/Device/nRF51822_xxAB/: arm_startup_nrf51.s system_nrf51.c
  group left out of the first target's files
    RTE/Device/nRF51822_xxAA/: arm_startup_nrf51.s system_nrf51.c
target nrf51822_xxaa_s120 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: as above
  output: gzll_nrfready_desktop_device_emulator_nrf51 +hex
  c flags: Optim=1 uC99=1
  c define: NRF51, NRF51822_QFAA_CA
  c include: as above
  memory RVCT4: ROM 0x00018000 size 0x00027000
  memory RVCT9: RAM 0x20002800 size 0x00001800
target nrf51822_xxab_s120 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: as above
  output: gzll_nrfready_desktop_device_emulator_nrf51 +hex
  c flags: Optim=1 uC99=1
  c define: NRF51, NRF51822_QFAA_CA
  c include: as above
  memory RVCT4: ROM 0x00018000 size 0x00007000
  memory RVCT9: RAM 0x20002800 size 0x00001800
  group added to the first target's files
    RTE/Device/nRF51822_xxAB/: arm_startup_nrf51.s system_nrf51.c
  group left out of the first target's files
    RTE/Device/nRF51822_xxAA/: arm_startup_nrf51.s system_nrf51.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
